# IAR project 000-STM32G031K8_StarterProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G031K8 ST STM32G031K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G031xx
  ICCARM.CCIncludePath2: ..\CMSIS_5\CMSIS\Core\Include; ..\STM32G0xx\Device\Include; ..\..\..\Lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    ../STM32G0xx/Device/Source/: system_stm32g0xx.c
  group Src
    ../../../Lib/src/: clock.c gpio.c switch.c uart.c
  group System
    ./: startup_stm32g031xx.s
